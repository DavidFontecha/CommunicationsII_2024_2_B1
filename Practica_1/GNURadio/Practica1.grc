options:
  parameters:
    generate_options: qt_gui
    id: Practica1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Acumulador
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Acumulador
    max: '10'
    min: '-10'
    type: float
  states: {}
- name: Desviaciòn_Estandar
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Desviaciòn Estandar
    max: '10'
    min: '-10'
    type: float
  states: {state: disabled}
- name: Diferenciador
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Diferenciador
    max: '10'
    min: '-10'
    type: float
  states: {state: disabled}
- name: Media
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Media
    max: '10'
    min: '-10'
    type: float
  states: {state: disabled}
- name: Media_Cuadratica
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Media Cuadratica
    max: '10'
    min: '-10'
    type: float
  states: {state: disabled}
- name: Potencia_Promedio
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Potencia Promedio
    max: '10'
    min: '-10'
    type: float
  states: {state: disabled}
- name: RMS
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: RMS
    max: '10'
    min: '-10'
    type: float
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (5, 12, -8)
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (0,2,1)
  states: {}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (5, 5, -10)
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nclass blk (gr. sync_block ):\n\tdef __init__ ( self ) : # only default arguments here\n\t\tgr. sync_block . __init__ (\n\t\t\tself ,\n\t\t\tname =\"Bloque acumulador\", # will show up in GRC\n\t\t\tin_sig =[ np. float32 ],\n\t\t\tout_sig =[ np. float32 ]\n\t\t)\n\t\t\n\tdef work (self , input_items , output_items ):\n\t\tx = input_items [0] # Senial de entrada .\n\t\ty0 = output_items [0] # Senial acumulada\n\t\t\n\t\tlimited_x = x[:2]\n\t\t\n\t\ty0 [:] = np.cumsum(limited_x)\n\t\t\n\t\treturn len(y0)\n___________________________________________________________________________________________________\n\t\nimport numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name=\"Bloque acumulador\",  # Nombre del bloque en GRC\n            in_sig=[np.float32],       # Tipo de la señal de entrada\n            out_sig=[np.float32]       # Tipo de la señal de salida\n        )\n        \n    def work(self, input_items, output_items):\n        x = input_items[0]  # Señal de entrada\n        y0 = output_items[0]  # Señal acumulada\n        \n        # Limitamos la señal de entrada a los primeros 2 elementos\n        limited_x = x[:2]\n        \n        # Calculamos la suma acumulativa de los primeros 2 elementos\n        if len(limited_x) >= 0:\n            acumulado_limited_x = np.cumsum(limited_x)[-1]  # Solo tomamos el último valor acumulado\n        else:\n            acumulado_limited_x = 0\n        \n        # Asignamos el valor acumulado a toda la salida\n        y0[:] = acumulado_limited_x\n        \n        return len(x)\n\n"
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      class blk (gr.sync_block ):
      	def __init__ ( self ) : # only default arguments here
      		gr. sync_block.__init__ (
      			self ,
      			name ="Bloque diferenciador", # will show up in GRC
      			in_sig =[ np.float32 ],
      			out_sig =[ np.float32 ]
      		)
      		self.acum_anterior = 0
      		
      	def work (self , input_items , output_items ):
      		x = input_items [0] # Senial de entrada .
      		y0 = output_items [0] # Senial acumulada diferencial
      		
      		N = len (x)
      		diff = np. cumsum (x) - self . acum_anterior
      		self . acum_anterior = diff [N -1]
      		y0 [:] = diff
      		return len (y0)
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      class blk (gr. sync_block ):
      	def __init__ ( self ) : # only default arguments here
      		gr. sync_block . __init__ (
      			self ,
      			name = "Promedios de tiempos", # will show up in GRC
      			in_sig =[ np. float32 ],
      			out_sig =[ np. float32 ,np. float32 ,np. float32 ,np. float32 ,np. float32 ]
      		)
      		self . acum_anterior = 0
      		self . Ntotales = 0
      		self . acum_anterior1 = 0
      		self . acum_anterior2 = 0
      	
      	def work (self , input_items , output_items ):
      		x = input_items [0] # Senial de entrada .
      		y0 = output_items [0] # Promedio de la senial
      		y1 = output_items [1] # Media de la senial
      		y2 = output_items [2] # RMS de la senial
      		y3 = output_items [3] # Potencia promedio de la senial
      		y4 = output_items [4] # Desviacion estandar de la senial

      		# Calculo del promedio
      		N = len (x)
      		self . Ntotales = self . Ntotales + N
      		acumulado = self . acum_anterior + np. cumsum (x)
      		self . acum_anterior = acumulado [N -1]
      		y0 [:]= acumulado / self . Ntotales
      	
      		# Calculo de la media cuadratica
      		x2=np. multiply (x,x)
      		acumulado1 = self . acum_anterior1 + np. cumsum (x2)
      		self . acum_anterior1 = acumulado [N -1]
      		y1 [:] = acumulado1 / self . Ntotales
      		
      		# Calculo de la RMS
      		y2 [:] = np. sqrt (y1)
      		
      		# Calculo de la potencia promedio
      		y3 [:] = np. multiply (y2 ,y2)
      		
      		# Calculo de la desviacion estandar
      		x3 = np. multiply (x-y0 ,x-y0)
      		acumulado2 = self . acum_anterior2 + np. cumsum (x3)
      		self . acum_anterior2 = acumulado2 [N -1]
      		y4 [:] = np. sqrt ( acumulado2 / self . Ntotales )
      		
      		return len (x)
  states: {state: disabled}

connections:
- [blocks_vector_source_x_0, '0', epy_block_2, '0']
- [blocks_vector_source_x_0_0, '0', epy_block_0, '0']
- [blocks_vector_source_x_0_1, '0', epy_block_1, '0']
- [epy_block_0, '0', Acumulador, '0']
- [epy_block_1, '0', Diferenciador, '0']
- [epy_block_2, '0', Media, '0']
- [epy_block_2, '1', Media_Cuadratica, '0']
- [epy_block_2, '2', RMS, '0']
- [epy_block_2, '3', Potencia_Promedio, '0']
- [epy_block_2, '4', Desviaciòn_Estandar, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
